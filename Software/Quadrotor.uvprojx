# Keil uVision project Quadrotor.uvprojx, settings and files
target Quadrotor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Quadrotor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xB
  c include: .\User\Include;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\STM32F1xx\Include;.\Drivers\HAL\Include;.\Peripherals\Include;.\Hardware\Include;.\Math\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers\CMSIS\STM32F1xx\Source
    ./Drivers/CMSIS/STM32F1xx/Source/: startup_stm32f103xb.s system_stm32f1xx.c
  group Drivers\HAL\Source
    ./Drivers/HAL/Source/: stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c
  group Peripherals\Source
    ./Peripherals/Source/: i2c.c spi.c timer2.c
  group Hardware\Source
    ./Hardware/Source/: led.c mpu6050.c nrf24l01.c motor.c
  group Math\Source
    ./Math/Source/: my_math.c
  group User\Source
    ./User/Source/: interrupt.c main.c system.c control.c
